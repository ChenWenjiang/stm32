# Keil uVision project 15_USBMouse.uvproj, settings and files
target 15_USBMouse (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USBMouse +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,ARC_TOUCHSCREEN,ARC_USB_MOUSE
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\include;..\..\..\Utilities\USB_Mouse\include;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --verbose
  group User
    ../: USBMouse_main.c
  group ARC_Utilities
    ../../../Utilities/Retarget/: ARC_Retarget.c
    ../../../Utilities/SysTick/: ARC_SysTick.c
    ../../../Utilities/LCD/: ARC_LCD.c
    ../../../Utilities/USART/: ARC_USART.c
    ../../../Utilities/RCC/: ARC_RCC.c
    ../../../Utilities/GPIO/: ARC_GPIO.c
    ../../../Utilities/Touch_Screen/: ARC_TouchScreen.c
    ../../../Utilities/SPI/: ARC_SPI.c
    ../../../Utilities/EXTI/: ARC_EXTI.c
    ../../../Utilities/NVIC_API/: ARC_NVIC_API.c
    ../../../Utilities/SPI_Flash/: ARC_SPI_Flash.c
    ../../../Utilities/Button_EXTI/: ARC_Button_EXTI.c
    ../../../Utilities/USB_Mouse/: ARC_USBMouse.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_it.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group USBFSPeriph_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_regs.c usb_int.c usb_sil.c usb_mem.c usb_init.c
  group ARC_USB
    ../../../Utilities/USB_Mouse/src/: hw_config.c usb_prop.c usb_istr.c usb_desc.c usb_pwr.c usb_endp.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
