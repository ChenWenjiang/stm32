# Keil uVision project 16_ucos.uvproj, settings and files
target 16_ucos (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ucos +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\include;..\..\..\rtos\uCOS\uC-LIB;..\..\..\rtos\uCOS\uC-CPU;..\..\..\rtos\uCOS\uC-CPU\ARM-Cortex-M3\MDK;..\..\..\rtos\uCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\MDK;..\..\..\rtos\uCOS\uCOS-III\Source;..\..\..\rtos\uCOS\uCOS-CFG;..\..\..\rtos\uCOS\uC-BSP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --verbose
  group User
    ../: ucos_main.c
  group ARC_Utilities
    ../../../Utilities/RCC/: ARC_RCC.c
    ../../../Utilities/GPIO/: ARC_GPIO.c
    ../../../Utilities/LED/: ARC_LED.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group uC/OS-III
    ../../../rtos/uCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../rtos/uCOS/uCOS-III/Ports/ARM-Cortex-M3/Generic/MDK/: os_cpu_c.c os_cpu_a.s
  group uC/CPU
    ../../../rtos/uCOS/uC-CPU/: cpu_core.c
    ../../../rtos/uCOS/uC-CPU/ARM-Cortex-M3/MDK/: cpu_c.c cpu_a.s
  group uC/LIB
    ../../../rtos/uCOS/uC-LIB/: lib_math.c lib_ascii.c lib_mem.c lib_str.c
    ../../../rtos/uCOS/uC-LIB/Ports/ARM-Cortex-M3/MDK/: lib_mem_a.s
  group uC/BSP
    ../../../rtos/uCOS/uC-BSP/: bsp.c
