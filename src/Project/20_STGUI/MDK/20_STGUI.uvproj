# Keil uVision project 20_STGUI.uvproj, settings and files
target 20_ST_GUI (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ST_GUI +hex
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,ARC_STGUI
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\include;..\..\..\GUI\ST\Embedded_GUI_Gen\inc;..\..\..\GUI\ST\Embedded_GUI_HAL\inc;..\..\..\GUI\ST\Embedded_GUI_Library\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --verbose
  group User
    ../: st_gui_main.c
  group ARC_Utilities
    ../../../Utilities/Retarget/: ARC_Retarget.c
    ../../../Utilities/SysTick/: ARC_SysTick.c
    ../../../Utilities/USART/: ARC_USART.c
    ../../../Utilities/RCC/: ARC_RCC.c
    ../../../Utilities/GPIO/: ARC_GPIO.c
    ../../../Utilities/SPI/: ARC_SPI.c
    ../../../Utilities/EXTI/: ARC_EXTI.c
    ../../../Utilities/NVIC_API/: ARC_NVIC_API.c
    ../../../Utilities/SPI_Flash/: ARC_SPI_Flash.c
    ../../../Utilities/Button_EXTI/: ARC_Button_EXTI.c
    ../../../Utilities/LCD/: ARC_LCD_ST.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_it.c stm32f10x_flash.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group GUI_HAL
    ../../../GUI/ST/Embedded_GUI_HAL/src/: JoyHal.c TscHal.c touchscreen.c
  group GUI_Lib
    ../../../GUI/ST/Embedded_GUI_Library/src/: cursor.c gl_fonts.c graphicObject.c images.c
  group GUI_Gen
    ../../../GUI/ST/Embedded_GUI_Gen/src/: pictures.c uiappuser.c uiframework.c
