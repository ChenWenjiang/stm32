# Keil uVision project 18_fatfs.uvproj, settings and files
target 18_fatfs (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fatfs +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,ARC_FATFS
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\include;..\..\..\fileSys\ff9\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --verbose
  group User
    ../: fatfs_main.c
  group ARC_Utilities
    ../../../Utilities/USART/: ARC_USART.c
    ../../../Utilities/Retarget/: ARC_Retarget.c
    ../../../Utilities/SD/: ARC_SD.c
    ../../../Utilities/SysTick/: ARC_SysTick.c
    ../../../Utilities/GPIO/: ARC_GPIO.c
    ../../../Utilities/RCC/: ARC_RCC.c
    ../../../Utilities/SPI/: ARC_SPI.c
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c
    ../../../Utilities/DMA/: ARC_DMA.c
    ../../../Utilities/RTC/: ARC_RTC.c
    ../../../Utilities/Fatfs/: ARC_Fatfs.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_it.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group FATFS
    ../../../fileSys/ff9/src/: ff.c
